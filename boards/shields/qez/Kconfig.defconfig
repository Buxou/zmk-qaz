## boards/shields/qez/Kconfig.defconfig
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

if SHIELD_QEZ

config ZMK_KEYBOARD_NAME
    default "QEZ"

endif
```
